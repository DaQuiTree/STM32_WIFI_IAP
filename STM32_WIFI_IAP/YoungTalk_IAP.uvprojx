# Keil uVision project YoungTalk_IAP.uvprojx, settings and files
target Target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WIFI_IAP +hex
  AfterMake: E:\Keil\keil5\ARM\ARMCC\bin\fromelf.exe --bin --output .\Objects\WIFI_IAP.bin .\Objects\WIFI_IAP.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\inc;.\Lib\SRC;.\System;.\Basic\sys;.\Basic\delay;.\User;.\Hardware\LED;.\Basic\flash;.\Hardware\KEY;.\Hardware\ESP32\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartupCode
    ./StartupCode/: startup_stm32f10x_md.s
  group System
    ./System/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Lib
    ./Lib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_usart.c
  group User
    ./User/: crc.c main.c stm32f10x_it.c iap.c
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/flash/: flash.c
    ./Hardware/ESP32/src/: usart.c
  group HardWare
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/ESP32/src/: tcp.c esp8266.c
  group Doc
    ./Doc/: issue.txt
